/*
*********************************************************************************************************
* 文件 : asm330.c
* 作者 : zqh			
* 版本 : V1.0
* 日期 : 2026/8/31
* 描述 : ASM330LHH六轴传感器寄存器层(含FIFO寄存器读写)
* 历史 :
*********************************************************************************************************
*/

#include "asm330.h"
#include "app_spi.h"
#include "mbserial_slave_port.h"

/*
*********************************************************************************************************
* 函数名 : ASM330_ParaInit
* 入口参数 : reg - 寄存器地址
* 返回值 : 读取到的寄存器值
* 说明 : 读取ASM330LHH单个寄存器
*********************************************************************************************************
*/

uint8_t ASM330_ParaInit(uint8_t reg)
{
    return App_SpiReadRegByte(reg);
}


/*
*********************************************************************************************************
* 函数名 : ASM330_ReadRegByte
* 入口参数 : reg - 寄存器地址
* 返回值 : 读取到的寄存器值
* 说明 : 读取ASM330LHH单个寄存器
*********************************************************************************************************
*/

uint8_t ASM330_ReadRegByte(uint8_t reg)
{
    return App_SpiReadRegByte(reg);
}

/*
*********************************************************************************************************
* 函数名 : ASM330_WriteRegByte
* 入口参数 : reg - 寄存器地址
*          val - 要写入的寄存器值
* 返回值 : 写寄存器成功返回ASM330_OK，失败返回ASM330_ERROR
* 说明 : 写ASM330LHH单个寄存器
*********************************************************************************************************
*/

int32_t ASM330_WriteRegByte(uint8_t reg, uint8_t val)
{
    return App_SpiWriteRegByte(reg, val);
}

/*
*********************************************************************************************************
* 函数名 : ASM330_ReadRegs
* 入口参数 : reg  - 起始寄存器地址
*          pbuf - 存放读取数据的缓冲区
*          len  - 读取的寄存器个数
* 返回值 : 读寄存器成功返回ASM330_OK，失败返回ASM330_ERROR
* 说明 : 连续读ASM330LHH多个寄存器
*********************************************************************************************************
*/

int32_t ASM330_ReadRegs(uint8_t reg, uint8_t *pbuf, uint16_t len)
{
    return App_SpiReadRegs(reg, pbuf, len);
}

/*
*********************************************************************************************************
* 函数名 : ASM330_WriteRegs
* 入口参数 : reg  - 起始寄存器地址
*          pbuf - 存放待写数据的缓冲区
*          len  - 写入的寄存器个数
* 返回值 : 写寄存器成功返回ASM330_OK，失败返回ASM330_ERROR
* 说明 : 连续写ASM330LHH多个寄存器
*********************************************************************************************************
*/

int32_t ASM330_WriteRegs(uint8_t reg, uint8_t *pbuf, uint16_t len)
{
    return App_SpiWriteRegs(reg, pbuf, len);
}

/*
*********************************************************************************************************
* 函数名 : ASM330_ReadFifoStatus
* 入口参数 : pwords - 返回FIFO中未读16位字数
*          pflags - 返回FIFO_STATUS2的标志字节
* 返回值 : 读取成功返回ASM330_OK，失败返回ASM330_ERROR
* 说明 : 读取FIFO状态：未读数据量(DIFF_FIFO[9:0])与各类标志
*********************************************************************************************************
*/

int32_t ASM330_ReadFifoStatus(uint16_t *pwords, uint8_t *pflags)
{
    uint8_t buf[2];

    if ((pwords == 0) || (pflags == 0)) {
        return ASM330_ERROR;
    }

    if (ASM330_ReadRegs(ASM330_FIFO_STATUS1_REG, buf, 2) != ASM330_OK) {
        return ASM330_ERROR;
    }

    *pwords = (uint16_t)(((uint16_t)(buf[1] & ASM330_FIFO_STATUS_DIFF_H_MSK) << 8) | (uint16_t)buf[0]);
    *pflags = buf[1];

    return ASM330_OK;
}

/*
*********************************************************************************************************
* 函数名 : ASM330_ReadFifoData
* 入口参数 : pbuf - 存放FIFO数据的缓冲区
*          len  - 读取字节数
* 返回值 : 读取成功返回ASM330_OK，失败返回ASM330_ERROR
* 说明 : 从FIFO_DATA_OUT_TAG寄存器起连续读取FIFO数据(TAG+数据)
*********************************************************************************************************
*/

int32_t ASM330_ReadFifoData(uint8_t *pbuf, uint16_t len)
{
    if ((pbuf == 0) || (len == 0)) {
        return ASM330_ERROR;
    }

    return ASM330_ReadRegs(ASM330_FIFO_DATA_OUT_TAG_REG, pbuf, len);
}

/*
*********************************************************************************************************
* 函数名 : ASM330_FifoReset
* 入口参数 : 无
* 返回值 : 复位成功返回ASM330_OK，失败返回ASM330_ERROR
* 说明 : 通过切入旁路模式清空FIFO(工作模式需由上层重新配置)
*********************************************************************************************************
*/

int32_t ASM330_FifoReset(void)
{
    return ASM330_WriteRegByte(ASM330_FIFO_CTRL4_REG, ASM330_FIFO_MODE_BYPASS);
}
